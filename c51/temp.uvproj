# Keil uVision project temp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: temp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group USER
    ./: STARTUP.A51 main.c
  group LIB
    ./lib/: onewire.c onewire.h display.c display.h headfile.h system.c system.h uart.c uart.h
